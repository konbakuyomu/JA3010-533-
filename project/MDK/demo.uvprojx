# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,__DEBUG
  c include: ..\..\drivers\cmsis\Include;..\..\drivers\hc32_ll_driver\inc;..\..\source;..\..\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\..\HardWare\SD\fs\inc;..\..\drivers\bsp\ev_hc32f460_lqfp100_v2;..\..\HardWare\I2C_Lcd_128x64
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\lpm_powerdown_wkup.sct
  link misc: --keep=*Handler
  group Bsp
    ../../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group common
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
  group driver
    ../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_interrupts.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32_ll_fcg.c hc32_ll_icg.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_qspi.c
  group source
    ../../source/: main.c APPRTC.c
software components: CMSIS:CORE 5.0.1
