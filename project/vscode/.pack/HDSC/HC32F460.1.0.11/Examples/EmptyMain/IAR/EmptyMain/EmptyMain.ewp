# IAR project EmptyMain.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: EmptyMain.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.2.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/Device Startup
    ${CMSIS_PACK_PATH_HDSC#HC32F460#1.0.11}$/Device/Include/: HC32F460PETB.h system_hc32f460.h
    ${CMSIS_PACK_PATH_HDSC#HC32F460#1.0.11}$/Device/Source/IAR/: startup_hc32f460.s
    ${CMSIS_PACK_PATH_HDSC#HC32F460#1.0.11}$/Device/Source/: system_hc32f460.c
