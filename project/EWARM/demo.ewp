# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\source; ..\..\drivers\cmsis; ..\..\drivers\cmsis\Device\HDSC\hc32f4xx\Include; ..\..\drivers\hc32_ll_driver\inc; ..\..\HardWare\Qspiflash; ..\..\HardWare\SD\fs\inc; ..\..\drivers\bsp\ev_hc32f460_lqfp100_v2; ..\..\drivers\cmsis\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: config\linker\HC32F460xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group common
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/IAR/: startup_hc32f460.s
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group driver
    ../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_crc.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group source
    ../../source/: APPRTC.c main.c
